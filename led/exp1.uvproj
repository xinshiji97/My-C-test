# Keil uVision project exp1.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: exp1 +hex
  AfterMake: E:\keil_5\ARM\ARMCC\bin\fromelf.exe  --bin !L --output  exp1.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT1: ROM 0x32000000 size 0x10000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x50000000 size 0x1000
  group Source Group 1
    ./: led.c
